Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView], RevitIdentifiers [VersionGUID: 1cd045ca-c12f-4411-b6f8-9ceeeeb301d1, NumberOfSaves: 1]
File name: Project Number
Time: 2026-06-17T10:51:33+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.3.416 (ENU) - IFC 24.0.3.416

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: ## StreetCity, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: ## StreetCity, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head (2)
Pset_ProductRequirements - Category: Levels
Other - Category: Levels; Family: Level; Family and Type: Level: 8mm Head; Type: 8mm Head; Type Id: 27
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Structural: no
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: 8mm Head
Name | LongName = Pset_AirSideSystemInformation, Name = Pset_ProductRequirements, Name = Identity Data, Name | Elevation (mm) = Constraints, Elevation (mm)
Level 1 | Level 1 | 0
Level 2 | Level 2 | 4000

# IfcBuildingElementProxy: Family2:Standard, Family2:Standard:209534
In: Level 1
Type - Material: Aluminium - flach_1
Type - Other - Category: Generic Models; Family Name: Family2
Type - Model Properties - Änderungsgrund: wall thickness increased; Artikelnummer: 10662000210; Author: FV; Creation Date: 21-Jul-25; Designer: FV; Design State: 1; Oberfläche: mill finish; OnLevel description DE: TF-6620 Glas Profil L=2500mm, Aluminium unbehandelt; OnLevel description DK: TF-6620 glasprofil L=2500mm, aluminium rå overfl.; OnLevel description EN: TF-6620 glass profile L=2500mm, aluminum mill finish; OnLevel description ES: TF-6620 perfil de vidrio L=2500mm, aluminio sin tratar; OnLevel description FR: TF-6620 profil verre L=2500mm, aluminium non traitée; OnLevel description GB: TF-6620 glass profile L=2500mm, aluminum mill finish; OnLevel description NL: TF-6620 glas profiel L=2500mm, aluminium onbehandeld; OnLevel description NO: TF-6620 glassprofil L=2500mm, aluminium rå overflate; OnLevel description RU: TF-6620 профиль стекла L=2500mm, oтделка алюм. mель.; OnLevel description SE: TF-6620 glasprofil L=2500mm, aluminium obehand. utför.; OnLevel description US: TF-6620 glass profile L=2500mm, aluminum mill finish; Part Number: 10662000210; Revision Number: 04; Revisionsnummer: 04; Title: 10662000210; Toleranzangabe: DIN EN 12020-2
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - Type Name: Standard
Type - Pset_ProductRequirements - Category: Generic Models
Pset_BuildingElementProxyCommon - Reference: Standard; sets with these values: 2
Other - Family: Family2; Family and Type: Family2: Standard; Type: Standard; Type Id: 209519
Constraints - Elevation from Level: 0 mm; Moves With Nearby Elements: no; Offset from Host: 0 mm
Dimensions - Area: 0.888522 m2; Volume: 0.0122436 m3
Phasing - Phase Created: New Construction
