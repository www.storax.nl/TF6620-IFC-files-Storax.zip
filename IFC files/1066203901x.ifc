Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView], RevitIdentifiers [VersionGUID: 6fec3769-5db0-424c-a912-09e26632c286, NumberOfSaves: 1]
File name: Project Number
Time: 2026-05-21T16:17:00+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.3.416 (ENU) - IFC 24.0.3.416

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: ## StreetCity, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: ## StreetCity, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head (2)
Pset_ProductRequirements - Category: Levels
Other - Category: Levels; Family: Level; Family and Type: Level: 8mm Head; Type: 8mm Head; Type Id: 27
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Structural: no
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: 8mm Head
Name | LongName = Pset_AirSideSystemInformation, Name = Pset_ProductRequirements, Name = Identity Data, Name | Elevation (mm) = Constraints, Elevation (mm)
Level 1 | Level 1 | 0
Level 2 | Level 2 | 4000

# IfcBuildingElementProxy: Family2:Standard, Family2:Standard:209542
In: Level 1
Type - Material: Aluminium - flach_1, Aluminium - flach_1(1)
Type - Other - Category: Generic Models; Family Name: Family2
Type - Model Properties - Artikelnummer: 10662039010; Author: frank; Breite: 0; Creation Date: 24-Oct-24; Designer: frank; Design State: 1; Gewicht: 0; Höhe: 0; Länge: 0; OnLevel description DE: TF-6620 Eckverbinder 90° innen/außen, Aluminium unbehandelt; OnLevel description DK: TF-6620 hjørne ind/udv, aluminium rå overfl.; OnLevel description EN: TF-6620 corner inside/outside, aluminum mill finish; OnLevel description ES: TF-6620 esquina 90° interior/exterior, aluminio sin tratar; OnLevel description FR: TF-6620 angle 90° intérieur/extérieur, aluminium non traitée; OnLevel description GB: TF-6620 corner inside/outside, aluminum mill finish; OnLevel description NL: TF-6620 hoek 90° binnen/buiten, aluminium onbehandeld; OnLevel description NO: TF-6620 hjørne innvendig/utvendig, aluminium rå overflate; OnLevel description RU: TF-6620 уголок внутри / снаружи, oтделка алюм. mель.; OnLevel description SE: TF-6620 ändlock vänster, aluminium obehand. utför.; OnLevel description US: TF-6620 corner inside/outside, aluminum mill finish; Part Number: S-10662039010; Revision Number: -; Revisionsnummer: 04; Toleranzangabe: ISO 2768 - m; Werkzeug: Nein
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - Type Name: Standard
Type - Pset_ProductRequirements - Category: Generic Models
Pset_BuildingElementProxyCommon - Reference: Standard; sets with these values: 2
Other - Family: Family2; Family and Type: Family2: Standard; Type: Standard; Type Id: 209527
Constraints - Elevation from Level: 0 mm; Moves With Nearby Elements: no; Offset from Host: 0 mm
Dimensions - Area: 0.127563 m2; Volume: 0.00158556 m3
Phasing - Phase Created: New Construction
