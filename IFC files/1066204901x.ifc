Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView], RevitIdentifiers [VersionGUID: a987b4bf-4e32-429a-a141-ed644125c156, NumberOfSaves: 1]
File name: Project Number
Time: 2026-07-14T11:59:53+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.3.416 (ENU) - IFC 24.0.3.416

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: ## StreetCity, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: ## StreetCity, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head (2)
Pset_ProductRequirements - Category: Levels
Other - Category: Levels; Family: Level; Family and Type: Level: 8mm Head; Type: 8mm Head; Type Id: 27
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Structural: no
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: 8mm Head
Name | LongName = Pset_AirSideSystemInformation, Name = Pset_ProductRequirements, Name = Identity Data, Name | Elevation (mm) = Constraints, Elevation (mm)
Level 1 | Level 1 | 0
Level 2 | Level 2 | 4000

# IfcBuildingElementProxy: Family2:Standard, Family2:Standard:209529
In: Level 1
Type - Material: Aluminum - Flat
Type - Other - Category: Generic Models; Family Name: Family2
Type - Model Properties - Artikelnummer: 10662049010; Author: FV; Creation Date: 11-Nov-24; Designer: frank; Design State: 1; Oberfläche: mill finish; OnLevel description DE: TURBOFLEX Endkappe TL-6620 links/rechts, Aluminium unbehandelt; OnLevel description Dk: TURBOFLEX endehætte TL-6620 venstre/højre, aluminium rå overfl.; OnLevel description EN: TURBOFLEX endcap TL-6620 left/right, aluminum mill finish; OnLevel description ES: TURBOFLEX tapón de acabado TL-6620 izq./der., aluminio sin tratar; OnLevel description FR: TURBOFLEX bouchon TL-6620 gauche/droite, aluminium non traitée; OnLevel description GB: TURBOFLEX endcap TL-6620 left/right, aluminum mill finish; OnLevel description NL: TURBOFLEX eindkap TL-6620 links/rechts, aluminium onbehandeld; OnLevel description NO: TURBOFLEX endekap TL-6620 venstre/ikke sant, aluminium rå overflate; OnLevel description RU: TURBOFLEX плоская крышка TL-6620 оставил/правильно, oтделка алюм. mель.; OnLevel description SE: TURBOFLEX ändlock TL-6620 vänster/höger, aluminium obehand. utför.; OnLevel description US: TURBOFLEX endcap TL-6620 left/right, aluminum mill finish; Part Number: 10662049010; Toleranzangabe: ISO 2768 - m; toleranzangage: ISO 2768-m; Werkzeug: Nein
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - Type Name: Standard
Type - Pset_ProductRequirements - Category: Generic Models
Pset_BuildingElementProxyCommon - Reference: Standard; sets with these values: 2
Other - Family: Family2; Family and Type: Family2: Standard; Type: Standard; Type Id: 209514
Constraints - Elevation from Level: 0 mm; Moves With Nearby Elements: no; Offset from Host: 0 mm
Dimensions - Area: 0.0119304 m2; Volume: 0.0000639262 m3
Phasing - Phase Created: New Construction
