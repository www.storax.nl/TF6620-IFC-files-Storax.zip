Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView], RevitIdentifiers [VersionGUID: 6d550273-ee5b-4f0d-b208-68e56471c625, NumberOfSaves: 1]
File name: Project Number
Time: 2025-07-02T13:57:03+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.3.416 (ENU) - IFC 24.0.3.416

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: ## StreetCity, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: ## StreetCity, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head (2)
Pset_ProductRequirements - Category: Levels
Other - Category: Levels; Family: Level; Family and Type: Level: 8mm Head; Type: 8mm Head; Type Id: 27
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Structural: no
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: 8mm Head
Name | LongName = Pset_AirSideSystemInformation, Name = Pset_ProductRequirements, Name = Identity Data, Name | Elevation (mm) = Constraints, Elevation (mm)
Level 1 | Level 1 | 0
Level 2 | Level 2 | 4000

# IfcBuildingElementProxy: Family5:Standard, Family5:Standard:209527
In: Level 1
Type - Material: Aluminum - Flat(1)
Type - Other - Category: Generic Models; Family Name: Family5
Type - Model Properties - Artikelnummer: 10662050010; Author: FV; Creation Date: 11/17/2014; Designer: FV; Design State: 1; Oberfläche: mill finish; OnLevel description DE: Abstandsplatte TL-6620, dicke 18mm Aluminium unbehandelt; OnLevel description DK: Afstand stk. TL-6620, tykkelse 18mm aluminium rå Overfl.; OnLevel description EN: Spacer TL-6620, thickness 18mm aluminum mill finish; OnLevel description ES: Spacer TL-6620, espesor 18mm aluminio sin tratar; OnLevel description FR: Écarteur TL-6620, épaisseur 18mm aluminium brut; OnLevel description GB: Spacer TL-6620, thickness 18mm aluminum mill finish; OnLevel description NL: Afstandhouder TL-6620, dikte 18mm aluminium onbehandeld; OnLevel description NO: Afstand stk. TL-6620, tykkelse 18mm aluminium rå overflate; OnLevel description RU: Проставка TL-6620, толщина 18mm отделка алюминиевого проката; OnLevel description SE: Distanslist TL-6620, tjocklek 18mm alum. obehand. utför.; OnLevel description US: Spacer TL-6620, thickness 18mm aluminum mill finish; Part Number: 10662050010; Title: 10602050010; Toleranzangabe: DIN EN 12020 - 2
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - Type Name: Standard
Type - Pset_ProductRequirements - Category: Generic Models
Pset_BuildingElementProxyCommon - Reference: Standard; sets with these values: 2
Other - Family: Family5; Family and Type: Family5: Standard; Type: Standard; Type Id: 209512
Constraints - Elevation from Level: 0 mm; Moves With Nearby Elements: no; Offset from Host: 0 mm
Dimensions - Area: 0.0078288 m2; Volume: 0.0000561198 m3
Phasing - Phase Created: New Construction

# IfcOpeningElement: Opening, Family5:Standard:209527:1
In: Level 1
Pset_OpeningElementCommon - Reference: Standard; sets with these values: 2
Pset_ProductRequirements - Category: Generic Models
